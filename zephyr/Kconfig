## zephyr/Kconfig
```kconfig
menu "app_dns_lib options"

config APP_DNS_LIB
    bool "Enable app_dns_lib Library"
    default y
    help
      Enable support for app_dns_lib.


endmenu
```
